# Keil uVision project prj.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: clock.c clock.h GPIOs.c GPIOs.h main.c util.c util.h timer.c USART.h USART.c adc.c adc.h command.h command.c
software components: CMSIS:CORE 4.2.0, Device:DMA 1.2, Device:Startup 1.0.0
